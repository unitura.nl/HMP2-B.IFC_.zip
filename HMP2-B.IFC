Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView]
File name: C:\Users\MarloesAertsUnitura\HSR Groep BV\Unitura - Documenten\Producten\1. Faunavoorzieningen\2. Houtbeton\3. INBOUW VOGELS & INSECTEN\1. GZ-HMP2, HO-SP-VLP1\2. Tekeningen\HMP2-B.IFC
Time: 2026-09-22T14:21:10+00:00
Author: none
Organization: none
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC2X3
Authorization: none

# IfcProject, Project
Description: Default Project
